MOV TMOD, #20H
MOV TH1, #0FDH
MOV SCON, #50H
SETB TR1
MOV DPTR, #MYDATA
H_1: CLR A
	 MOVC A, @A+DPTR
	 JZ B_1
	 ACALL SEND
	 INC DPTR
	 SJMP H_1
B_1: MOV A, P2
	 ACALL SEND
	 ACALL RECV
	 MOV P1, A
	 SJMP B_1
SEND: MOV SBUF, A
H_2: JNB TI, H_2
	 CLR TI
	 RET
RECV: JNB RI, RECV
	 MOV A, SBUF
	 CLR RI
	 RET
MYDATA: DB "HELLO WORLD"	 
END